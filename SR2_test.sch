v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -2230 -330 -2170 -330 {lab=Vdd}
N -2400 -330 -2230 -330 {lab=Vdd}
N -2520 -330 -2400 -330 {lab=Vdd}
N -2520 -50 -2350 -50 {lab=Clk}
N -2170 -110 -2170 30 {lab=0}
N -2520 30 -2170 30 {lab=0}
N -1750 -330 -1690 -330 {lab=Vdd}
N -1920 -330 -1750 -330 {lab=Vdd}
N -2040 -330 -1920 -330 {lab=Vdd}
N -1870 -170 -1870 -50 {lab=Clk}
N -2040 -50 -1870 -50 {lab=Clk}
N -1690 -110 -1690 30 {lab=0}
N -2040 30 -1690 30 {lab=0}
N -2170 -330 -2040 -330 {lab=Vdd}
N -2350 -50 -2040 -50 {lab=Clk}
N -2170 30 -2040 30 {lab=0}
N -2160 -330 -2160 -270 {lab=Vdd}
N -2300 -330 -2300 -230 {lab=Vdd}
N -2320 -170 -2300 -170 {lab=Clk}
N -2320 -170 -2320 -50 {lab=Clk}
N -2360 -150 -2300 -150 {lab=Vdd}
N -2360 -330 -2360 -150 {lab=Vdd}
N -1870 -170 -1820 -170 {lab=Clk}
N -1920 -150 -1820 -150 {lab=Vdd}
N -1920 -330 -1920 -150 {lab=Vdd}
N -1820 -330 -1820 -230 {lab=Vdd}
N -1680 -330 -1680 -270 {lab=Vdd}
N -1690 -330 -1680 -330 {lab=Vdd}
N -1270 -330 -1210 -330 {lab=Vdd}
N -1440 -330 -1270 -330 {lab=Vdd}
N -1560 -330 -1440 -330 {lab=Vdd}
N -1390 -170 -1390 -50 {lab=Clk}
N -1560 -50 -1390 -50 {lab=Clk}
N -1210 -110 -1210 30 {lab=0}
N -1560 30 -1210 30 {lab=0}
N -1390 -170 -1340 -170 {lab=Clk}
N -1440 -150 -1340 -150 {lab=Vdd}
N -1440 -330 -1440 -150 {lab=Vdd}
N -1340 -330 -1340 -230 {lab=Vdd}
N -1200 -330 -1200 -270 {lab=Vdd}
N -1210 -330 -1200 -330 {lab=Vdd}
N -1870 -50 -1500 -50 {lab=Clk}
N -1690 30 -1500 30 {lab=0}
N -1680 -330 -1500 -330 {lab=Vdd}
N -790 -330 -730 -330 {lab=Vdd}
N -960 -330 -790 -330 {lab=Vdd}
N -1080 -330 -960 -330 {lab=Vdd}
N -910 -170 -910 -50 {lab=Clk}
N -1080 -50 -910 -50 {lab=Clk}
N -730 -110 -730 30 {lab=0}
N -1080 30 -730 30 {lab=0}
N -910 -170 -860 -170 {lab=Clk}
N -960 -150 -860 -150 {lab=Vdd}
N -960 -330 -960 -150 {lab=Vdd}
N -860 -330 -860 -230 {lab=Vdd}
N -720 -330 -720 -270 {lab=Vdd}
N -730 -330 -720 -330 {lab=Vdd}
N -310 -330 -250 -330 {lab=Vdd}
N -480 -330 -310 -330 {lab=Vdd}
N -600 -330 -480 -330 {lab=Vdd}
N -430 -170 -430 -50 {lab=Clk}
N -600 -50 -430 -50 {lab=Clk}
N -250 -110 -250 30 {lab=0}
N -600 30 -250 30 {lab=0}
N -430 -170 -380 -170 {lab=Clk}
N -480 -150 -380 -150 {lab=Vdd}
N -480 -330 -480 -150 {lab=Vdd}
N -380 -330 -380 -230 {lab=Vdd}
N -240 -330 -240 -270 {lab=Vdd}
N -250 -330 -240 -330 {lab=Vdd}
N -910 -50 -540 -50 {lab=Clk}
N -730 30 -540 30 {lab=0}
N -720 -330 -540 -330 {lab=Vdd}
N -1390 -50 -1080 -50 {lab=Clk}
N -1210 30 -1090 30 {lab=0}
N -1090 30 -1080 30 {lab=0}
N -1200 -330 -1080 -330 {lab=Vdd}
N 170 -330 230 -330 {lab=Vdd}
N 0 -330 170 -330 {lab=Vdd}
N -120 -330 0 -330 {lab=Vdd}
N 50 -170 50 -50 {lab=Clk}
N -120 -50 50 -50 {lab=Clk}
N 230 -110 230 30 {lab=0}
N -120 30 230 30 {lab=0}
N 50 -170 100 -170 {lab=Clk}
N 0 -150 100 -150 {lab=Vdd}
N 0 -330 0 -150 {lab=Vdd}
N 100 -330 100 -230 {lab=Vdd}
N 240 -330 240 -270 {lab=Vdd}
N 230 -330 240 -330 {lab=Vdd}
N 650 -330 710 -330 {lab=Vdd}
N 480 -330 650 -330 {lab=Vdd}
N 360 -330 480 -330 {lab=Vdd}
N 530 -170 530 -50 {lab=Clk}
N 360 -50 530 -50 {lab=Clk}
N 710 -110 710 30 {lab=0}
N 360 30 710 30 {lab=0}
N 530 -170 580 -170 {lab=Clk}
N 480 -150 580 -150 {lab=Vdd}
N 480 -330 480 -150 {lab=Vdd}
N 580 -330 580 -230 {lab=Vdd}
N 720 -330 720 -270 {lab=Vdd}
N 710 -330 720 -330 {lab=Vdd}
N 50 -50 420 -50 {lab=Clk}
N 230 30 420 30 {lab=0}
N 240 -330 420 -330 {lab=Vdd}
N 1130 -330 1190 -330 {lab=Vdd}
N 960 -330 1130 -330 {lab=Vdd}
N 840 -330 960 -330 {lab=Vdd}
N 1010 -170 1010 -50 {lab=Clk}
N 840 -50 1010 -50 {lab=Clk}
N 1190 -110 1190 30 {lab=0}
N 840 30 1190 30 {lab=0}
N 1010 -170 1060 -170 {lab=Clk}
N 960 -150 1060 -150 {lab=Vdd}
N 960 -330 960 -150 {lab=Vdd}
N 1060 -330 1060 -230 {lab=Vdd}
N 1200 -330 1200 -270 {lab=Vdd}
N 1190 -330 1200 -330 {lab=Vdd}
N 1610 -330 1670 -330 {lab=Vdd}
N 1440 -330 1610 -330 {lab=Vdd}
N 1320 -330 1440 -330 {lab=Vdd}
N 1490 -170 1490 -50 {lab=Clk}
N 1320 -50 1490 -50 {lab=Clk}
N 1670 -110 1670 30 {lab=0}
N 1320 30 1670 30 {lab=0}
N 1490 -170 1540 -170 {lab=Clk}
N 1440 -150 1540 -150 {lab=Vdd}
N 1440 -330 1440 -150 {lab=Vdd}
N 1540 -330 1540 -230 {lab=Vdd}
N 1680 -330 1680 -270 {lab=Vdd}
N 1670 -330 1680 -330 {lab=Vdd}
N 1010 -50 1380 -50 {lab=Clk}
N 1190 30 1380 30 {lab=0}
N 1200 -330 1380 -330 {lab=Vdd}
N 530 -50 840 -50 {lab=Clk}
N 710 30 830 30 {lab=0}
N 830 30 840 30 {lab=0}
N 720 -330 840 -330 {lab=Vdd}
N -430 -50 -120 -50 {lab=Clk}
N -250 30 -120 30 {lab=0}
N -240 -330 -120 -330 {lab=Vdd}
N 2090 -330 2150 -330 {lab=Vdd}
N 1920 -330 2090 -330 {lab=Vdd}
N 1800 -330 1920 -330 {lab=Vdd}
N 1970 -170 1970 -50 {lab=Clk}
N 1800 -50 1970 -50 {lab=Clk}
N 2150 -110 2150 30 {lab=0}
N 1800 30 2150 30 {lab=0}
N 1970 -170 2020 -170 {lab=Clk}
N 1920 -150 2020 -150 {lab=Vdd}
N 1920 -330 1920 -150 {lab=Vdd}
N 2020 -330 2020 -230 {lab=Vdd}
N 2160 -330 2160 -270 {lab=Vdd}
N 2150 -330 2160 -330 {lab=Vdd}
N 1670 30 1800 30 {lab=0}
N 1490 -50 1800 -50 {lab=Clk}
N 1680 -330 1800 -330 {lab=Vdd}
C {lab_pin.sym} -2520 -50 0 0 {name=p2 sig_type=std_logic lab=Clk}
C {lab_pin.sym} -2520 -330 0 0 {name=p3 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} -2300 -200 0 0 {name=p4 sig_type=std_logic lab=D1}
C {lab_pin.sym} -2000 -220 2 0 {name=p5 sig_type=std_logic lab=Q1}
C {gnd.sym} -2520 30 0 0 {name=l1 lab=0}
C {code_shown.sym} -2600 -580 0 0 {name=s2 only_toplevel=false value="
.lib /usr/local/share/pdk/sky130A/libs.tech/ngspice/sky130.lib.spice tt
.tran .1u 20u
.save all
.end
"}
C {vsource.sym} -3140 -70 0 0 {name=Vdd value=1.8 savecurrent=false}
C {vsource.sym} -3140 40 0 0 {name=Vclk value= "PULSE(0 1.8 1n .1n .1n 100n 200n)"  savecurrent=false}
C {lab_pin.sym} -3140 -100 2 0 {name=p8 sig_type=std_logic lab=Vdd}
C {lab_pin.sym} -3140 10 2 0 {name=p10 sig_type=std_logic lab=Clk}
C {gnd.sym} -3140 70 0 0 {name=l3 lab=0}
C {gnd.sym} -3140 -40 0 0 {name=l5 lab=0}
C {vsource.sym} -2960 350 0 0 {name=Vdata2 value= "PULSE(0 1.8 0 .1n .1n 2u 4u)" savecurrent=false}
C {lab_pin.sym} -2960 320 2 0 {name=p16 sig_type=std_logic lab=D2}
C {gnd.sym} -2960 380 0 0 {name=l6 lab=0}
C {vsource.sym} -3160 350 0 0 {name=Vdata1 value= "PULSE(0 1.8 0 .1n .1n 5u 10u)" savecurrent=false}
C {lab_pin.sym} -3160 320 2 0 {name=p17 sig_type=std_logic lab=D1}
C {gnd.sym} -3160 380 0 0 {name=l7 lab=0}
C {lab_pin.sym} -1820 -200 0 0 {name=p7 sig_type=std_logic lab=D2}
C {lab_pin.sym} -1520 -220 2 0 {name=p9 sig_type=std_logic lab=Q2}
C {vsource.sym} -2760 350 0 0 {name=Vdata3 value= "PULSE(0 1.8 0 .1n .1n 1u 2u)" savecurrent=false}
C {lab_pin.sym} -2760 320 2 0 {name=p11 sig_type=std_logic lab=D3}
C {gnd.sym} -2760 380 0 0 {name=l2 lab=0}
C {vsource.sym} -2590 360 0 0 {name=Vdata4 value= "PULSE(0 1.8 0 .1n .1n 5u 10u)" savecurrent=false}
C {lab_pin.sym} -2590 330 2 0 {name=p14 sig_type=std_logic lab=D4}
C {gnd.sym} -2590 390 0 0 {name=l4 lab=0}
C {vsource.sym} -2400 360 0 0 {name=Vdata5 value= "PULSE(0 1.8 0 .1n .1n .5u 1u)" savecurrent=false}
C {lab_pin.sym} -2400 330 2 0 {name=p19 sig_type=std_logic lab=D5}
C {gnd.sym} -2400 390 0 0 {name=l8 lab=0}
C {vsource.sym} -2960 500 0 0 {name=Vdata6 value= "PULSE(0 1.8 0 .1n .1n 2u 4u)" savecurrent=false}
C {lab_pin.sym} -2960 470 2 0 {name=p30 sig_type=std_logic lab=D7}
C {gnd.sym} -2960 530 0 0 {name=l9 lab=0}
C {vsource.sym} -3160 500 0 0 {name=Vdata7 value= "PULSE(0 1.8 0 .1n .1n 5u 10u)" savecurrent=false}
C {lab_pin.sym} -3160 470 2 0 {name=p31 sig_type=std_logic lab=D6}
C {gnd.sym} -3160 530 0 0 {name=l10 lab=0}
C {vsource.sym} -2760 500 0 0 {name=Vdata8 value= "PULSE(0 1.8 0 .1n .1n 1u 2u)" savecurrent=false}
C {lab_pin.sym} -2760 470 2 0 {name=p32 sig_type=std_logic lab=D8}
C {gnd.sym} -2760 530 0 0 {name=l11 lab=0}
C {vsource.sym} -2590 510 0 0 {name=Vdata9 value= "PULSE(0 1.8 0 .1n .1n 5u 10u)" savecurrent=false}
C {lab_pin.sym} -2590 480 2 0 {name=p33 sig_type=std_logic lab=D9}
C {gnd.sym} -2590 540 0 0 {name=l12 lab=0}
C {vsource.sym} -2400 510 0 0 {name=Vdata10 value= "PULSE(0 1.8 0 .1n .1n .5u 1u)" savecurrent=false}
C {lab_pin.sym} -2400 480 2 0 {name=p34 sig_type=std_logic lab=D10}
C {gnd.sym} -2400 540 0 0 {name=l13 lab=0}
C {/home/jetha/Projects/sky130/SAR_ADC/D_flipflop/DFF2.sym} -2150 -190 0 0 {name=x11}
C {/home/jetha/Projects/sky130/SAR_ADC/D_flipflop/DFF2.sym} -1670 -190 0 0 {name=x1}
C {lab_pin.sym} -1340 -200 0 0 {name=p1 sig_type=std_logic lab=D3}
C {lab_pin.sym} -1040 -220 2 0 {name=p6 sig_type=std_logic lab=Q3}
C {/home/jetha/Projects/sky130/SAR_ADC/D_flipflop/DFF2.sym} -1190 -190 0 0 {name=x2}
C {lab_pin.sym} -860 -200 0 0 {name=p12 sig_type=std_logic lab=D4}
C {lab_pin.sym} -560 -220 2 0 {name=p13 sig_type=std_logic lab=Q4}
C {/home/jetha/Projects/sky130/SAR_ADC/D_flipflop/DFF2.sym} -710 -190 0 0 {name=x3}
C {lab_pin.sym} -380 -200 0 0 {name=p15 sig_type=std_logic lab=D5}
C {lab_pin.sym} -80 -220 2 0 {name=p18 sig_type=std_logic lab=Q5}
C {/home/jetha/Projects/sky130/SAR_ADC/D_flipflop/DFF2.sym} -230 -190 0 0 {name=x4}
C {lab_pin.sym} 100 -200 0 0 {name=p20 sig_type=std_logic lab=D6}
C {lab_pin.sym} 400 -220 2 0 {name=p21 sig_type=std_logic lab=Q6}
C {/home/jetha/Projects/sky130/SAR_ADC/D_flipflop/DFF2.sym} 250 -190 0 0 {name=x5}
C {lab_pin.sym} 580 -200 0 0 {name=p22 sig_type=std_logic lab=D7}
C {lab_pin.sym} 880 -220 2 0 {name=p23 sig_type=std_logic lab=Q7}
C {/home/jetha/Projects/sky130/SAR_ADC/D_flipflop/DFF2.sym} 730 -190 0 0 {name=x6}
C {lab_pin.sym} 1060 -200 0 0 {name=p24 sig_type=std_logic lab=D8}
C {lab_pin.sym} 1360 -220 2 0 {name=p25 sig_type=std_logic lab=Q8}
C {/home/jetha/Projects/sky130/SAR_ADC/D_flipflop/DFF2.sym} 1210 -190 0 0 {name=x7}
C {lab_pin.sym} 1540 -200 0 0 {name=p26 sig_type=std_logic lab=D9}
C {lab_pin.sym} 1840 -220 2 0 {name=p27 sig_type=std_logic lab=Q9}
C {/home/jetha/Projects/sky130/SAR_ADC/D_flipflop/DFF2.sym} 1690 -190 0 0 {name=x8}
C {lab_pin.sym} 2020 -200 0 0 {name=p28 sig_type=std_logic lab=D10}
C {lab_pin.sym} 2320 -220 2 0 {name=p29 sig_type=std_logic lab=Q10}
C {/home/jetha/Projects/sky130/SAR_ADC/D_flipflop/DFF2.sym} 2170 -190 0 0 {name=x9}
